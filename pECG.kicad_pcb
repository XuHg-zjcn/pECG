# Repository XuHg-zjcn/pECG

File README.md:

# 便携式心电监测仪

## 目标功能
- 单导联心电
- 呼吸监测
- 加速度计
- 显示心率、呼吸数据和心电波形
- 更换电池不中断数据记录

## 主要元器件
|名称           |型号(或候选)     |
|:--------------|:----------------|
|模拟前端       |ADS1292R         |
|无线MCU        |CH583M           |
|电池           |10280圆柱体锂电池|
|显示屏         |彩色TFT屏        |

## 参考资料
- [Protocentral/ADS1292rShield_Breakout](https://github.com/Protocentral/ADS1292rShield_Breakout/tree/master)
- [TI官方 ADS1292R资料](https://www.ti.com/product/ADS1292R)

## 版权和许可证
Copyright (C) 2026  徐瑞骏  
本设计使用的为许可证“CERN Open Hardware Licence Version 2 - Strongly Reciprocal”

## KiCad design pECG.kicad_pcb

Parts:
BT1: 3.7v; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
C1, C2: 1uF; C_0402_1005Metric
C3: 20p; C_0402_1005Metric
C4: 1.5nF; C_0402_1005Metric
C5, C6, C13, C18: 10uf; C_0805_2012Metric
C7, C11, C19, C20: 100nf; C_0402_1005Metric
C9: 10nf; C_0402_1005Metric
C15, C16: 100n; C_0402_1005Metric
C21, C23, C24, C25: 2.2nF; C_0402_1005Metric
C22: 47uf; CP_EIA-3216-18_Kemet-A
C26: 4.7n; C_0402_1005Metric
C27: 47n; C_0402_1005Metric
C28, C29, C33: 0.1u; C_0402_1005Metric
C30, C31, C32: 1u; C_0402_1005Metric
D1: LED; LED_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
J2: USB_C_Receptacle_USB2.0_14P; USB_C_Receptacle_Palconn_UTC16-G
J4: AudioJack3; Jack_3.5mm_CUI_SJ-3523-SMT_Horizontal
R1: R; R_0603_1608Metric
R2: R; R_0402_1005Metric
R3, R4: 40.2k; R_0402_1005Metric
R5: 100k; R_0402_1005Metric
R6, R11, R12: 0; R_0402_1005Metric
R7, R8, R9, R10: 10M; R_0402_1005Metric
R13: 1M; R_0402_1005Metric
R14: 0.4; R_1206_3216Metric
R15, R16: 10k; R_0402_1005Metric
U1: VQFN-32-1EP_4x4mm_P0.4mm_EP2.8x2.8mm_ThermalVias
U2: SPX3819M5-L-3-3; SOT-23-5
U4: TP4065; TSOT-23-5

Connections:
+3.3V: C28.2, C31.2, U1.23 (DVDD)
+3.3VA: C6.1, C29.2, C30.2, FB1.2, R7.1, R8.1, U1.12 (AVDD)
+3V3: C11.1, C13.1, FB1.1, U2.5 (OUT)
+BATT: BT1.1 (+), C5.1, C7.1, C20.1, C22.1, U2.1 (IN), U4.3 (BAT)
/CLK_512K: U1.17 (CLK)
/CS_ADS1292R: U1.18 (~CS)
/DPWR_EN: U2.3 (EN)
/LA: C16.1, R12.2, R16.1
/LA_R: C16.2, C23.1, C25.1, R8.2, R10.1
/MISO: U1.21 (DOUT)
/MOSI: U1.19 (DIN)
/RA: C15.1, R11.2, R15.1
/RA_R: C15.2, C21.1, C24.1, R7.2, R9.1
/RL: C4.1, R5.1, R6.2, R13.1, U1.30 (RLDOUT)
/SCLK: U1.20 (SCLK)
/USB_D+: J2.A6 (D+), J2.B6 (D+)
/USB_D-: J2.A7 (D-), J2.B7 (D-)
GND: BT1.2 (-), C1.2, C2.2, C5.2, C6.2, C7.2, C9.2, C11.2, C13.2, C18.2, C19.2, C20.2, C22.2, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R2.2, R9.2, R10.2, U1.10 (VREFN), U1.13 (AVSS), U1.14 (CLKSEL), U1.24 (DGND), U1.33 (EP), U2.2 (GND), U4.2 (GND)
unnamed: C24.2, R3.1
unnamed: C25.2, R4.1
unnamed: D1.2 (A), R1.2
unnamed: D1.1 (K), U4.1 (~CHRG)
unnamed: J4.R, R11.1
unnamed: J4.S, R6.1
unnamed: J4.T, R12.1
unnamed: C21.2, U1.3 (IN1N)
unnamed: C23.2, U1.4 (IN1P)
unnamed: C3.1, R15.2, U1.5 (IN2N)
unnamed: C3.2, R16.2, U1.6 (IN2P)
unnamed: C27.1, U1.1 (PGA1N)
unnamed: C27.2, U1.2 (PGA1P)
unnamed: C26.2, U1.7 (PGA2N)
unnamed: C26.1, U1.8 (PGA2P)
unnamed: R3.2, U1.32 (RESP_MODN/IN3N)
unnamed: R4.2, U1.31 (RESP_MODP/IN3P)
unnamed: C4.2, R13.2, U1.28 (RLDINV)
unnamed: R5.2, U1.29 (RLDIN/RLDREF)
unnamed: C1.1, U1.11 (VCAP1)
unnamed: C2.1, U1.27 (VCAP2)
unnamed: C32.2, C33.2, U1.9 (VREFP)
unnamed: C9.1, U2.4 (BP)
unnamed: R2.1, U4.5 (PROG)
unnamed: C18.1, C19.1, R1.1, R14.2, U4.4 (VCC)
VBUS: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R14.1

Notes on the sheet:
MCU预选CH583

Board: 2 copper layers, 52 parts (1 on the bottom side), 38 nets.

## Commit log

2026-06-13 初始化提交，已绘制原理图模拟前端和电源部分
2026-06-13 添加许可证
2026-06-16 PCB部分布局和布线
